<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\evse_technolaf.ewp</path>
  </project>
  <batchBuild />
</workspace>
